# Keil uVision project Project.uvprojx, settings and files
target STM32F407VGTx (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.10.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32F407xx, USE_STM32F4_DISCO
  c include: ..\Inc;..\CubeLib\Drivers\STM32F4xx_HAL_Driver\Inc;..\CubeLib\Drivers\BSP\STM32F4-Discovery;..\CubeLib\Middlewares\Third_Party\FreeRTOS\Source\include;..\CubeLib\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS;..\CubeLib\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\Src\Log;..\CubeLib\CMSIS\Include;..\Src\CLI;..\Src\CLI\FreeRTOS-Plus-CLI;..\Src\CLI\serial_console;..\Src\PS2;..\Src\Touchpad;..\Src\GLCD;..\Src\CAN;..\Src\Key
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../Src/: main.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group User_Config
    ../Inc/: stm32f4xx_hal_conf.h FreeRTOSConfig.h
  group HAL_Driver
    ../CubeLib/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_dfsdm.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dsi.c stm32f4xx_hal_eth.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hash.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_irda.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_lptim.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_nand.c stm32f4xx_hal_nor.c stm32f4xx_hal_pccard.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_spdifrx.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_usb.c
  group BSP
    ../CubeLib/Drivers/BSP/STM32F4-Discovery/: stm32f4_discovery.c
  group Doc
    ../: Doc.txt
  group FreeRTOS
    ../CubeLib/Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../CubeLib/Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../CubeLib/Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group CMSIS_OS
    ../CubeLib/Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Serial
    ../Src/Log/: fifo.c serial.c serial_log.c
  group CLI
    ../Src/CLI/: Sample-CLI-commands.c
    ../Src/CLI/FreeRTOS-Plus-CLI/: FreeRTOS_CLI.c
    ../Src/CLI/serial_console/: command_console.c console_ctrl.c cmd_history.c
  group ps2
    ../Src/PS2/: ps2_io.c ps2_io.h
    ../Src/Touchpad/: touchpad.c touchpad.h mouse.c mouse.h
  group lcd
    ../Src/GLCD/: AsciiLib.c AsciiLib.h font.c GLCD.c GLCD.h HzLib.c HzLib.h LCDConf.h
  group CAN
    ../Src/CAN/: can.c can.h
  group Key
    ../Src/Key/: Key.c Key.h
software components: CMSIS:CORE 5.0.2, Device:Startup 2.5.0
